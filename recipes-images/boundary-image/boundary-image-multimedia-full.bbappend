IMAGE_INSTALL:append = " kernel-module-nrc-mod kernel-module-spi-ft232h-mod nrc-cli"
